# Build tensorflow 2.x by default
TF_ARGS_EXTRA ??= "--config=v2"

# Uncomment the following line to build tensorflow 1.x
#TF_ARGS_EXTRA = "--config=v1"
